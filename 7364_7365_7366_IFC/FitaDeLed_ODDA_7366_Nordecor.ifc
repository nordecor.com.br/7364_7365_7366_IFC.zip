Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-11-04T12:27:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 04 12:27:37 2025 * Host: MichellyManno * Database: C:\Users\miche\AppData\Local\Temp\91bb3417-47db-4dc8-a911-5057eaedd61b\0c0347d3-01f4-431b-af7f-a0a154b5bf36\ifc * Database version: 5507 * Database creation date: Tue Nov 04 12:27:37 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 04 12:27:37 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 04 12:27:37 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_328271
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 7366 - 4000K, FitaDeLed_ODDA_7364_7365_7366_Nordecor_IFC:7366 - 4000K:328271
In: Nível 1
Type - Material: Fita de LED
Type - Cotas - Largura da fita: 10 mm; Padrão de corte da fita: 18 mm
Type - Dados - Data de atualização: 25/10/2025; Versão: 1
Type - Dados de identidade - Código Uniformat: D5020.20; Comentários de tipos: fita de LED, temperaturas 2700K / 3000K / 4000K, fluxo luminoso 1200 lm/m, eficiência 1325 lm/W e 1371 lm/W, 168 LEDs por metro, iluminação linear contínua, uso interno, compatível com perfis de alumínio; Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Fita de LED, 4000K 1371Lm/m 168LEDs/m; Descrição UniFormat: Luminárias integradas ao edifício; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 anos; IP: 20; Localização: Camboriú/SC - Brasil; Modelo: 7366; Nome do tipo: 7366 - 4000K; Nota-chave: 26 56 33.19; Número MasterFormat: 26 56 33; Número OmniClass: 23.80.70.11.11; Tipo de fixação: Adesivo autocolante; Tipo de imagem: Imagem raster: 7364_7365_7366.JPG; Tipo de luminária: Distribuição Direta / Linear Contínua; Título MasterFormat: Luminárias Lineares; Título OmniClass: General Luminaries, Non Directional; URL: https://nordecor.com.br/; URL do desenvolvedor: https://checkbim.com.br/; URL do produto_Product Website: https://nordecor.com.br/produto/fita-led-odda-168leds-m-12v-14w-m-ip20-2-700k-3-000k-4-000k-irc97/
Type - Elétrico - Comentários de voltagem: 12VDC - Aplicação remota; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - fita de LED: 0 W
Type - Engenharia elétrica - Fator de potência - fita de LED: 1; Voltagem - fita de LED: 0 V
Type - Estrutural - Peso da luminária: 0.125
Type - Fotométricos - Fluxo luminoso: 1371 lm; IRC: 97; Potência: 14 W; Temperatura da cor: 4000 K
Type - Outros - Categoria: Luminárias; 2700K: no; 3000K: no; 4000K: yes; Nome da família: FitaDeLed_ODDA_7364_7365_7366_Nordecor_IFC
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - Fonte lum.: yes
Pset_DistributionFlowElementCommon - Reference: 7366 - 4000K; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Área: 0.011098 m2; Comprimento: 1000 mm; Comprimento real: 1008 mm; Volume: 0.00001008 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no; FonteID: 0
Fase - Fase criada: Construção nova
Outros - Família: FitaDeLed_ODDA_7364_7365_7366_Nordecor_IFC: 7366 - 4000K; Família e tipo: FitaDeLed_ODDA_7364_7365_7366_Nordecor_IFC: 7366 - 4000K; ID de tipo: FitaDeLed_ODDA_7364_7365_7366_Nordecor_IFC: 7366 - 4000K; Tipo: FitaDeLed_ODDA_7364_7365_7366_Nordecor_IFC: 7366 - 4000K
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
Visibilidade - 2D: yes
